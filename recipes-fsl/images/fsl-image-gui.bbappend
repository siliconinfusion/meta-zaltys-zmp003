# Copyright (C) 2015 - 2016 Silicon Infusion Ltd
# Released under the MIT license (see COPYING.MIT for the terms)

IMAGE_INSTALL += " linux-firmware-rtl8192cu "
IMAGE_INSTALL += " dhcp-client "
IMAGE_INSTALL += " chromium "
IMAGE_INSTALL += " packagegroup-core-buildessential "
IMAGE_INSTALL += " git "
IMAGE_INSTALL += " python3-core "

